# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: .\User;.\Libraries\STM32F4xx_HAL_Driver\Inc;.\Libraries\CMSIS;.\APP\led;.\Public;.\APP\beep;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\rng;.\APP\wkup;.\APP\adc;.\APP\mux;.\Gizwits;.\Utils;.\APP\TIMER;.\APP\USART3;.\APP\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f429xx.s
  group HAL_Driver
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmSimd.h core_cmInstr.h
    ./APP/time/: time.c
  group APP
    ./APP/led/: led.c
    ./APP/adc/: adc.c
    ./APP/mux/: mux.c
    ./APP/time/: time.c
    ./APP/USART3/: usart3.c
    ./APP/key/: key.c
  group Public
    ./Public/: usart.c system.c delay.c
  group Gizwits
    ./Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ./Utils/: common.c dataPointTools.c ringbuffer.c
